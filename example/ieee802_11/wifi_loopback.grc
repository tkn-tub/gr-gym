options:
  parameters:
    category: Custom
    generate_options: qt_gui
    hier_block_src_path: '~.grc_gnuradio/:'
    id: wifi_loopback
    output_language: python
    run: 'False'
  states: {}

blocks:
- name: chan_est
  id: variable_qtgui_chooser
  parameters:
    labels: '["LS", "LMS", "STA", "Linear Comb"]'
    num_opts: '0'
    options: '[ieee802_11.LS, ieee802_11.LMS, ieee802_11.STA, ieee802_11.COMB]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: encoding
  id: variable_qtgui_chooser
  parameters:
    labels: '["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-20e-6'
    step: '1e-6'
    stop: '20e-6'
    value: '0'
  states: {}
- name: interval
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '10'
    step: '1'
    stop: '1000'
    value: '300'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1500'
    value: '500'
  states: {}
- name: snr
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-15'
    step: '0.1'
    stop: '30'
    value: '15'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/sascha/project_openai_gnuradio/tests/wifi.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/gr_seq_recv
    type: int
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: /tmp/gr_seq_missing_recv
    type: int
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /tmp/gr_snr_vect
    type: float
    unbuffered: 'True'
    vlen: '64'
  states: {}
- name: blocks_file_sink_3
  id: blocks_file_sink
  parameters:
    file: /tmp/gr_seq_send
    type: int
    unbuffered: 'True'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    period: interval
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (10**(snr/10.0))**.5
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: epsilon * 5.89e9 / 10e6
    noise_voltage: '1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size
    pad_front: '500'
    pad_tail: '0'
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '127'
  states: {state: disabled}
- name: gnugym_gnugym_moving_average_vect_ff_0
  id: gnugym_gnugym_moving_average_vect_ff
  parameters:
    buffer: '3'
    vlen: '64'
  states: {}
- name: gnugym_gnugym_rssi_cb_0
  id: gnugym_gnugym_rssi_cb
  parameters:
    algo: gnugym.LS
    bw: 10e6
    debug: 'False'
    freq: 5.89e9
    log: 'False'
  states: {}
- name: gnugym_parse_seqnr_0
  id: gnugym_parse_seqnr
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: gnugym_parse_seqnr_0_0
  id: gnugym_parse_seqnr
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: ieee802_11_parse_mac_0
  id: ieee802_11_parse_mac
  parameters:
    debug: 'True'
    log: 'False'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1+epsilon
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: 48*10
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Error Rate
    max: '100'
    min: '0'
    type: float
    unit1: Percent
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier
  parameters:
    bandwidth: 10e6
    chan_est: chan_est
    encoding: encoding
    frequency: 5.89e9
    sensitivity: '0.56'
  states: {}
- name: xmlrpc_server_1
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee802_11_mac_0, app in]
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', qtgui_number_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', pfb_arb_resampler_xxx_0, '0']
- [foo_packet_pad2_0, '0', blocks_multiply_const_vxx_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [gnugym_gnugym_moving_average_vect_ff_0, '0', blocks_file_sink_2, '0']
- [gnugym_gnugym_rssi_cb_0, '0', gnugym_gnugym_moving_average_vect_ff_0, '0']
- [gnugym_parse_seqnr_0, '0', blocks_null_sink_0, '0']
- [gnugym_parse_seqnr_0, '1', blocks_file_sink_3, '0']
- [gnugym_parse_seqnr_0_0, '0', blocks_file_sink_1_1, '0']
- [gnugym_parse_seqnr_0_0, '1', blocks_file_sink_1, '0']
- [ieee802_11_mac_0, phy out, gnugym_parse_seqnr_0, in]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [ieee802_11_parse_mac_0, fer, blocks_pdu_to_tagged_stream_0, pdus]
- [pfb_arb_resampler_xxx_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', gnugym_gnugym_rssi_cb_0, '0']
- [wifi_phy_hier_0, '1', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, carrier, blocks_pdu_to_tagged_stream_0_0, pdus]
- [wifi_phy_hier_0, mac_out, foo_wireshark_connector_0, in]
- [wifi_phy_hier_0, mac_out, gnugym_parse_seqnr_0_0, in]
- [wifi_phy_hier_0, mac_out, ieee802_11_parse_mac_0, in]

metadata:
  file_format: 1
