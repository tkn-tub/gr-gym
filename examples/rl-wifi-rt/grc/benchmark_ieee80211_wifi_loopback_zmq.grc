options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: benchmark_ieee80211_wifi_loopback_zmq
    output_language: python
    realtime_scheduling: '1'
    run: 'False'
  states: {}

blocks:
- name: chan_est
  id: variable
  parameters:
    value: ieee802_11.LS
  states: {}
- name: dist
  id: variable
  parameters:
    value: '10'
  states: {}
- name: encoding
  id: variable
  parameters:
    value: '0'
  states: {}
- name: epsilon
  id: variable
  parameters:
    value: '0'
  states: {}
- name: interval
  id: variable
  parameters:
    value: '10'
  states: {}
- name: out_buf_size
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: pdu_length
  id: variable
  parameters:
    value: '10'
  states: {}
- name: snr
  id: variable
  parameters:
    value: '25'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    period: interval
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: (10**((snr-3.875-dist)/10.0))**.5
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: int
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: epsilon * 5.89e9 / 10e6
    noise_voltage: '0.3'
    seed: '0'
    taps: '1.0'
  states: {}
- name: foo_packet_pad2_0
  id: foo_packet_pad2
  parameters:
    debug: 'False'
    delay: 'False'
    delay_sec: '0.001'
    minoutbuf: out_buf_size * 10
    pad_front: '500'
    pad_tail: '0'
  states: {}
- name: gnugym_gnugym_msg_src_0
  id: gnugym_gnugym_msg_src
  parameters:
    msg: pmt.intern("".join("x" for i in range(pdu_length)))
    trigger: encoding
  states: {}
- name: gnugym_gnugym_rssi_cb_0
  id: gnugym_gnugym_rssi_cb
  parameters:
    bw: 10e6
    debug: 'False'
    freq: 5.89e9
    log: 'False'
  states: {}
- name: gnugym_parse_seqnr_0
  id: gnugym_parse_seqnr
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: gnugym_parse_seqnr_1
  id: gnugym_parse_seqnr
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11_mac_0
  id: ieee802_11_mac
  parameters:
    bss_mac: '[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]'
    dst_mac: '[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]'
    src_mac: '[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'GrGym actions:'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'GrGym sim channel:'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: 'GrGym config.yaml:'
  states: {}
- name: note_0_0_0_0
  id: note
  parameters:
    note: 'GrGym channel sim:'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: 1+epsilon
    type: ccf
  states: {}
- name: wifi_phy_hier_0
  id: wifi_phy_hier_fft
  parameters:
    bandwidth: 10e6
    chan_est: chan_est
    encoding: encoding
    frequency: 5.9e6
    sensitivity: '0.56'
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: 127.0.0.1
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:8001
    timeout: '100'
    type: int
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:8003
    timeout: '100'
    type: float
    vlen: '64'
  states: {}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:8002
    timeout: '100'
    type: int
  states: {}

connections:
- [blocks_message_strobe_0, strobe, ieee802_11_mac_0, app in]
- [blocks_multiply_const_xx_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', pfb_arb_resampler_xxx_0, '0']
- [foo_packet_pad2_0, '0', blocks_multiply_const_xx_0, '0']
- [gnugym_gnugym_msg_src_0, strobe, blocks_message_debug_0, print]
- [gnugym_gnugym_msg_src_0, strobe, ieee802_11_mac_0, app in]
- [gnugym_gnugym_rssi_cb_0, '0', zeromq_pub_sink_0_0, '0']
- [gnugym_parse_seqnr_0, '0', zeromq_pub_sink_1, '0']
- [gnugym_parse_seqnr_0, '1', blocks_null_sink_1_0_0, '0']
- [gnugym_parse_seqnr_1, '0', zeromq_pub_sink_0, '0']
- [gnugym_parse_seqnr_1, '1', blocks_null_sink_1_0, '0']
- [ieee802_11_mac_0, phy out, gnugym_parse_seqnr_1, in]
- [ieee802_11_mac_0, phy out, wifi_phy_hier_0, mac_in]
- [pfb_arb_resampler_xxx_0, '0', wifi_phy_hier_0, '0']
- [wifi_phy_hier_0, '0', foo_packet_pad2_0, '0']
- [wifi_phy_hier_0, '1', gnugym_gnugym_rssi_cb_0, '0']
- [wifi_phy_hier_0, mac_out, gnugym_parse_seqnr_0, in]

metadata:
  file_format: 1
