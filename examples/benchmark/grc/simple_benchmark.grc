options:
  parameters:
    generate_options: no_gui
    id: simple_benchmark
    output_language: python
    realtime_scheduling: '1'
    title: Simple benchmark
  states: {}

blocks:
- name: action
  id: variable
  parameters:
    value: '0'
  states: {}
- name: interval
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: action
    type: int
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: interval
    type: int
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:8001
    timeout: '100'
    type: int
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', zeromq_pub_sink_0_0, '0']

metadata:
  file_format: 1
