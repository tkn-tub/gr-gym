options:
  parameters:
    generate_options: no_gui
    id: simple_benchmark_pipe
    output_language: python
    realtime_scheduling: '1'
    title: Simple benchmark
  states: {}

blocks:
- name: action
  id: variable
  parameters:
    value: '0'
  states: {}
- name: interval
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: action
    type: int
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /tmp/obs
    type: int
    unbuffered: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: interval
    type: int
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', blocks_file_sink_1, '0']

metadata:
  file_format: 1
